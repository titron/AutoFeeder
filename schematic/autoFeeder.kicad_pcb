# Repository titron/AutoFeeder

File README.md:

AutoFeeder
==========

Feeding fish automatically.

Features:

* On-Off time 
* Feeding time
* Add-O2 time
* Current time.

## KiCad design schematic/autoFeeder.kicad_pcb

Parts:
C1, C2, C3, C5, C9, C10, C13: 0.1u; c_0805
C4, C8: 47u; c_1206
C6, C12: 4.7uF; c_0805
C7, C11: 10u; c_0805
CON1: BARREL_JACK
D1: Green; LED-0805
D2: Blue; LED-0805
D3: Red; LED-0805
D4: Yellow; LED-0805
D5, D6, D8: IN4148; SM1206
D7: 12V; SM1206
JP1, JP2, JP3: JUMPER; PIN_ARRAY_2X1
P1, P3: CONN_9X2; pin_array_9x2
P2: CONN_7X2; VASCH7x2
P4: CONN_30_OLED; CONN30_SMD
P5: CONN_2; GTK3mm5-H2
Q1: IRLML6402
Q2, Q3: IRLML6402; sot-23
R1, R2: 4.7K; SM0805
R3, R4, R5, R6: 1K; SM0805
R7: 50R; SM0805
R8: 1.2M; SM0805
R9, R10, R11: 47K; SM0805
SW1, SW2, SW3, SW4: SW_PUSH; SW_PUSH_12x12
SW5: SW_PUSH; SW_PUSH_SMALL
SW6: SPST; SW_SPDT_11x8
U1: R5F212A8; TQFP_64
U2: UPC2905AT; sc-63
U3: UPC2933AT; sc-63

Connections:
+3.3V: C1.1, C2.1, C3.1, C5.1, C11.1, P1.18, P2.8, Q3.2 (S), R1.1, R2.1, R11.1, U1.10 (VCC/AVCC), U1.61 (VREF), U1.62 (VCC/AVCC), U3.3
+3.3VP: C9.1, P4.17 (BS1), P4.24 (VDDIO), P4.26 (VCI), Q3.3 (D), R3.2, R4.2, R5.2, R6.2
+12P: C13.1, P4.3 (VCC), P4.29 (VCC), Q2.3 (D)
/CS#: P4.19 (CS#), U1.15 (P5_0/TRCCLK)
/D0: P4.13 (D0), U1.23 (P2_0/TRDIOA0/TRDCLK)
/D1: P4.12 (D1), U1.22 (P2_1/TRDIOB0)
/D2: P4.11 (D2), U1.21 (P2_2/TRDIOC0)
/D3: P4.10 (D3), U1.20 (P2_3/TRDIOD0)
/D4: P4.9 (D4), U1.19 (P2_4/TRDIOA1)
/D5: P4.8 (D5), U1.18 (P2_5/TRDIOB1)
/D6: P4.7 (D6), U1.17 (P2_6/TRDIOC1)
/D7: P4.6 (D7), U1.16 (P2_7/TRDIOD1)
/DC#: P4.18 (DC#), U1.14 (P5_1/TRCIOA/TRCTRG)
/P04: P1.5, U1.54 (P0_4/AN3)
/P05: P1.3, U1.57 (P0_5/AN2/CLK1)
/P06: P1.1, U1.58 (P0_6/AN1/DA0)
/P07: P1.16, U1.60 (P0_7/AN0/DA1)
/P10: P1.7, U1.49 (P1_0/~KI0~/AN8)
/P11: P1.9, U1.48 (P1_1/~KI1~/AN9)
/P12: P1.11, U1.47 (P1_2/~KI2~/AN10)
/P13: P1.13, U1.46 (P1_3/~KI3~/AN11)
/P14: P3.8, U1.27 (P1_4/TXD0)
/P15: P3.6, U1.26 (P1_5/RXD0/(TRAIO)/(~INT1~))
/P16: P3.4, U1.25 (P1_6/CLK0)
/P17: P3.2, U1.24 (P1_7/TRDIO/~INT1~)
/P30: P3.11, U1.43 (P3_0/TRAO)
/P31: P3.9, U1.42 (P3_1/TRBO)
/P32: P3.15, U1.45 (P3_2/(~INT2~))
/P34: P1.10, U1.2 (P3_4/SDA/~SCS~)
/P35: P1.12, U1.64 (P3_5/SCL/SSCK)
/P36: P3.13, U1.44 (P3_6/(INT1))
/P37: P1.14, U1.63 (P3_7/SSO)
/P43: P1.8, U1.4 (P4_3/XCIN)
/P44: P1.6, U1.5 (P4_4/XCOUT)
/P45: P3.1, U1.36 (P4_5/~INT0~)
/P46: P1.2, U1.9 (P4_6/XIN)
/P47: P1.4, U1.7 (P4_7/XOUT)
/P60: P3.16, U1.35 (P6_0/TREO)
/P63: P3.7, U1.41 (P6_3/TXD2)
/P64: P3.5, U1.40 (P6_4/RXD2)
/P65: P3.3, U1.39 (P6_5/(CLK1)/CLK2)
/P84: P3.14, U1.30 (P8_4/TRFO11)
/P85: P3.12, U1.29 (P8_5/TRF012)
/P86: P3.10, U1.28 (P8_6)
/RD#: P4.14 (E/RD#), U1.12 (P5_3/TRCIOC)
/RES#: P4.20 (RES#), U1.11 (P5_4/TRCIOD)
/RW#: P4.15 (R/W#), U1.13 (P5_2/TRCIOB)
CTL3V3: Q3.1 (G), R11.2, U1.55 (P6_2)
CTL12V: Q2.1 (G), R10.2, U1.56 (P6_1)
CTLMTR: Q1.1 (G), R9.2, U1.1 (P3_3/SSI)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, CON1.2, CON1.3, D5.2 (K), D7.1 (A), D8.1 (A), JP1.2, P1.15, P1.17, P2.2, P2.4, P2.6, P2.10, P2.12, P2.14, P3.17, P3.18, P4.1 (NC), P4.2 (VSS), P4.5 (VLSS), P4.16 (BS0), P4.28 (VLSS), P4.30 (NC), P5.2 (PM), R8.2, SW1.1, SW2.1, SW3.1, SW4.1, SW5.2, U1.8 (VSS/AVSS), U1.59 (VSS/AVSS), U2.2, U2.4, U3.2, U3.4
MODE: JP1.1, P2.7, R2.2, U1.3 (MODE)
unnamed: JP2.2, P2.5
unnamed: JP3.2, P2.11
unnamed: JP3.1, U1.38 (P6_7/~INT3~/RXD1)
unnamed: JP2.1, U1.37 (P6_6/~INT2~/TXD1)
unnamed: C7.1, Q1.2 (S), R9.1, U2.3
unnamed: SW4.2, U1.53 (P0_3/AN4)
unnamed: SW3.2, U1.52 (P0_2/AN5)
unnamed: SW2.2, U1.51 (P0_1/AN6)
unnamed: SW1.2, U1.50 (P0_0/AN7)
unnamed: D8.2 (K), P5.1, Q1.3 (D)
unnamed: D1.2 (K), U1.32 (P8_2/TRFO02)
unnamed: D4.2 (K), U1.33 (P8_1/TRFO01)
unnamed: C8.1, C10.1, D7.2 (K), Q2.2 (S), R10.1, SW6.2, U2.1, U3.1
unnamed: CON1.1, SW6.1
unnamed: D3.2 (K), U1.34 (P8_0/TRFO00)
unnamed: D2.1 (A), R6.1
unnamed: D2.2 (K), U1.31 (P8_3/TRFO10/TRFI)
unnamed: D3.1 (A), R3.1
unnamed: D4.1 (A), R4.1
unnamed: D1.1 (A), R5.1
unnamed: D5.1 (A), D6.2 (K)
unnamed: P4.22 (IREF), R8.1
unnamed: C6.1, P4.25 (VDD)
unnamed: P4.27 (VSL), R7.1
unnamed: C12.1, P4.4 (VCOM)
unnamed: D6.1 (A), R7.2
RST: C4.1, P2.13, R1.2, SW5.1, U1.6 (~RESET~)

Notes on the sheet:
*: For JP1,JP2,JP3 Short-UART Open-E8A

Board: 2 copper layers, 85.0 x 53.0 mm, 53 parts (38 on the bottom side), 79 nets.

## Code that names these connections

File refers/OLED/566424E.c (part):

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//-=-=-=-=-=-=-=-=-=-=-=-=-=-=-=-=-=-=-=-=-=-=-=-=-=-=-=-=-=-=-=-=-=-=-=
#define xData	P1				// Parallel Data Input/Output

#define SCLK	P1_0				// Serial Clock Input
#define SDIN	P1_1				// Serial Data Input

#define RES	P3_3				// Reset
#define CS	P3_4				// Chip Select
#define DC	P3_2				// Data/Command Control

#define E	P3_0				// Read/Write Enable
#define RW	P3_1				// Read/Write Select

#define RD	P3_0				// Read Signal
#define WR	P3_1				// Write Signal

//-=-=-=-=-=-=-=-=-=-=-=-=-=-=-=-=-=-=-=-=-=-=-=-=-=-=-=-=-=-=-=-=-=-=-=
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{
unsigned char i;

	RES=0;
	for(i=0;i<200;i++)
	{
		uDelay(200);
	}
	RES=1;

	Set_Display_Mode(0x01);			// Entire Display On Mode (0x00/0x01/0x02/0x03)

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{
unsigned char i;

	RES=0;
	for(i=0;i<200;i++)
	{
		uDelay(200);
	}
	RES=1;

	Set_Command_Lock(0x12);			// Unlock Basic Commands (0x12/0x16)
	Set_Display_On_Off(0x00);		// Display Off (0x00/0x01)
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
## Commit log

2014-03-05 initial version.
2014-03-05 test local repository。
2014-03-05 re-compile.
2014-03-05 add function description.
2014-03-06 clean out code, format, indent.
2014-03-06 clean out code(format, indent, comment).
2014-03-06 current time bar position changed; system struture added on spec.ppt.
2014-03-06 OLED spec added.
2014-03-06 OLED spec. added.
2014-03-12 test eclipse git env.
2014-03-12 DesignSpark PCB project.
2014-05-28 schematic in kicad complete.
2020-11-25 Continue to do with 2 functions: 1. Step motor to feed 2. control O2 pump
2020-11-25 Continue to develop with Step motor and control add-O2
2020-11-25 Modified features
2020-11-25 Add Stepper Motor materials
2020-11-25 Modified drv_stepper to R8C
2020-11-26 Added Stepper driver complete
2020-11-26 32bit env
2020-12-27 Feeding stepper OK；Adding O2 control(under Debug);
2021-01-08 Added O2 control

Notices in the files:
refers/OLED/566424E.c:
Copyright (c) Univision Technology Inc.
